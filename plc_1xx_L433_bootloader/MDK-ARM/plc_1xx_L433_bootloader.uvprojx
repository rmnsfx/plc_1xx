# Keil uVision project plc_1xx_L433_bootloader.uvprojx, settings and files
target plc_1xx_L433 (ARM-ADS)
  device: STM32L433CCUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: plc_1xx_L433_bootloader
  AfterMake: fromelf --bin --output .\PLC_1xx_bootloader.bin .\plc_1xx_L433\plc_1xx_L433_bootloader.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L433xx, ARM_MATH_CM4, __FPU_PRESENT
  c misc: --C99
  c include: ../Inc;             ../Drivers/STM32L4xx_HAL_Driver/Inc;             ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;             ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;             ../Drivers/CMSIS/Device/ST/STM32L4xx/Include;             ../Middlewares/Third_Party/FreeRTOS/Source/include;             ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;             ../Drivers/CMSIS/Include;             ..\Src;             ..\Src\display;             ..\Src\display
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: event_groups.c queue.c croutine.c timers.c tasks.c list.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Application/User
    ../Src/: main.c stm32l4xx_it.c stm32l4xx_hal_timebase_TIM.c freertos.c stm32l4xx_hal_msp.c Task_manager.c spi.c usart.c gpio.c dma.c tim.c adc.c dac.c Flash_manager.c iwdg.c
    ../Drivers/CMSIS/DSP_Lib/Source/FilteringFunctions/: arm_biquad_cascade_df1_f32.c arm_biquad_cascade_df1_init_f32.c
    ../Drivers/CMSIS/DSP_Lib/Source/StatisticsFunctions/: arm_rms_f32.c arm_max_f32.c arm_min_f32.c arm_mean_f32.c
    ../Src/display/: fonts.c ssd1306.c courierNew_10ptBitmaps.c dejavu_8x14.c dejavu_5x10.c
  group Application/MDK-ARM
    ./: startup_stm32l433xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_gpio.c stm32l4xx_hal_spi.c stm32l4xx_hal.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_adc.c stm32l4xx_hal_dac.c stm32l4xx_hal_cortex.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_pwr.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c
software components: CMSIS:CORE 4.1.0
